# IAR project sensorlib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM4F110B2QR TexasInstruments LM4F110B2QR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: sensorlib.srec
  ILINK.IlinkOutputFile: sensorlib.out
  group Source
    ./: ak8963.c ak8975.c bmp180.c cm3218.c comp_dcm.c i2cm_drv.c isl29023.c magneto.c mpu6050.c mpu9150.c sht21.c tmp006.c vector.c
