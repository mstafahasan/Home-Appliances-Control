# IAR project temperature_tmp006.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM4F120H5QR TexasInstruments LM4F120H5QR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PM; TARGET_IS_BLIZZARD_RB1; UART_BUFFERED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..\..
  OBJCOPY.OOCOutputFile: temperature_tmp006.bin
  ILINK.IlinkOutputFile: temperature_tmp006.out
  ILINK.IlinkIcfFile: temperature_tmp006.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../../sensorlib/ewarm/Exe/: sensorlib.a
  group Source
    ../drivers/: rgb.c
    ./: startup.c temperature_tmp006.c
    ../../../../utils/: uartstdio.c
