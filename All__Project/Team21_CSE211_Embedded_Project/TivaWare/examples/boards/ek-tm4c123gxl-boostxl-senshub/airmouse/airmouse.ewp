# IAR project airmouse.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM4F120H5QR TexasInstruments LM4F120H5QR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PM; TARGET_IS_BLIZZARD_RB1; UART_BUFFERED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..\..
  OBJCOPY.OOCOutputFile: airmouse.bin
  ILINK.IlinkOutputFile: airmouse.out
  ILINK.IlinkIcfFile: airmouse.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../../sensorlib/ewarm/Exe/: sensorlib.a
    ../../../../usblib/ewarm/Exe/: usblib.a
  group Source
    ./: airmouse.c lprf.c motion.c remoti_npi.c remoti_rtis.c remoti_uart.c startup.c usb_dev_comp_hid.c usb_structs.c
    ../drivers/: buttons.c rgb.c
    ../../../../utils/: ringbuf.c uartstdio.c
