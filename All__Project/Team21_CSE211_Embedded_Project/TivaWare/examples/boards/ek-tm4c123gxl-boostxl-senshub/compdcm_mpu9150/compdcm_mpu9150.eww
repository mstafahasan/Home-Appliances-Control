<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\compdcm_mpu9150.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\driverlib\driverlib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\sensorlib\sensorlib.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>driverlib</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>sensorlib</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>compdcm_mpu9150</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


