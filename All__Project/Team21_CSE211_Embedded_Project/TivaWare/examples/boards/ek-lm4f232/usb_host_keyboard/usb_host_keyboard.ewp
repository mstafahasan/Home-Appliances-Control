# IAR project usb_host_keyboard.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM4F232H5QD TexasInstruments LM4F232H5QD
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PGE; TARGET_IS_BLIZZARD_RA1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..\..
  OBJCOPY.OOCOutputFile: usb_host_keyboard.bin
  ILINK.IlinkOutputFile: usb_host_keyboard.out
  ILINK.IlinkIcfFile: usb_host_keyboard.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../../grlib/ewarm/Exe/: grlib.a
    ../../../../usblib/ewarm/Exe/: usblib.a
  group Source
    ../drivers/: cfal96x64x16.c
    ./: startup.c usb_host_keyboard.c
    ../../../../utils/: uartstdio.c
