<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\usb_host_keyboard.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\driverlib\driverlib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\grlib\grlib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\usblib\usblib.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>driverlib</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usblib</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>grlib</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_host_keyboard</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


