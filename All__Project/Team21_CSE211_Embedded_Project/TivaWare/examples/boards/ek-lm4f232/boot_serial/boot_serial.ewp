# IAR project boot_serial.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM4F232H5QD TexasInstruments LM4F232H5QD
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PGE; TARGET_IS_BLIZZARD_RA1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..\..\..\..; ..\..\..\..\boot_loader
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: boot_serial.bin
  ILINK.IlinkOutputFile: boot_serial.out
  ILINK.IlinkIcfFile: ..\..\..\..\boot_loader\bl_link.icf
  ILINK.IlinkProgramEntryLabel: ResetISR
  group Source
    ../../../../boot_loader/: bl_autobaud.c bl_can.c bl_check.c bl_decrypt.c bl_flash.c bl_i2c.c bl_main.c bl_packet.c bl_ssi.c bl_startup.S bl_uart.c bl_usb.c bl_usbfuncs.c
