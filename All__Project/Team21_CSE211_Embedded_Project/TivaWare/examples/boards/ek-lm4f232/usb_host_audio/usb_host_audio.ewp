# IAR project usb_host_audio.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM4F232H5QD TexasInstruments LM4F232H5QD
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PGE; TARGET_IS_BLIZZARD_RA1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..; ..\..\..\..\third_party
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: usb_host_audio.bin
  ILINK.IlinkOutputFile: usb_host_audio.out
  ILINK.IlinkIcfFile: usb_host_audio.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../../grlib/ewarm/Exe/: grlib.a
    ../../../../usblib/ewarm/Exe/: usblib.a
  group Source
    ../drivers/: buttons.c cfal96x64x16.c slidemenuwidget.c usb_sound.c wavfile.c
    ../../../../third_party/fatfs/src/: ff.c
    ../../../../third_party/fatfs/port/: mmc-ek-lm4f232h5qd.c
    ./: startup.c usb_host_audio.c
    ../../../../utils/: ustdlib.c
