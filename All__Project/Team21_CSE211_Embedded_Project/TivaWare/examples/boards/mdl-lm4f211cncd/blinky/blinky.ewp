# IAR project blinky.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM4F211H5QR TexasInstruments LM4F211H5QR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_TM4C123AH6PM; TARGET_IS_BLIZZARD_RA1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..\..
  OBJCOPY.OOCOutputFile: blinky.bin
  ILINK.IlinkOutputFile: blinky.out
  ILINK.IlinkIcfFile: blinky.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Source
    ./: blinky.c startup.c
